<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\msp430x54x_flashwrite_04.ewp</path>
  </project>
  <batchBuild/>
</workspace>


